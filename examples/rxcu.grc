options:
  parameters:
    generate_options: no_gui
    id: wifirxcu
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_100
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: freq_132
  id: variable
  parameters:
    value: 5660e6
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: '0.17'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/cloud/sdr/sig80211GenMultipleSiso_1x1_0.bin
    repeat: 'False'
    type: complex
  states: {}
- name: ieee80211_signal_0
  id: ieee80211_signal
  parameters: {}
  states: {}
- name: ieee80211_sync_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_trigger_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: ieee80211cu_demodcu_0
  id: ieee80211cu_demodcu
  parameters:
    mugid: '2'
    mupos: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9527'
    type: UDP_CLIENT
  states: {}
- name: presisocu_0
  id: presisocu
  parameters: {}
  states: {}

connections:
- [blocks_file_source_0, '0', ieee80211_signal_0, '1']
- [blocks_file_source_0, '0', ieee80211_sync_0, '2']
- [blocks_file_source_0, '0', presisocu_0, '0']
- [ieee80211_signal_0, '0', ieee80211cu_demodcu_0, '0']
- [ieee80211_sync_0, '0', ieee80211_signal_0, '0']
- [ieee80211_trigger_0, '0', ieee80211_sync_0, '0']
- [ieee80211cu_demodcu_0, out, network_socket_pdu_0, pdus]
- [presisocu_0, '0', ieee80211_trigger_0, '0']
- [presisocu_0, '1', ieee80211_sync_0, '1']

metadata:
  file_format: 1
