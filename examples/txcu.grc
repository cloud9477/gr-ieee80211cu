options:
  parameters:
    generate_options: qt_gui
    id: txcu
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_100
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: freq_112
  id: variable
  parameters:
    value: 5560e6
  states: {}
- name: freq_132
  id: variable
  parameters:
    value: 5660e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: txamp_range
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: ieee80211cu_genpkt_0
  id: ieee80211cu_genpkt
  parameters:
    tag: packet_len
  states: {}
- name: ieee80211cu_modcu_0
  id: ieee80211cu_modcu
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9528'
    type: UDP_SERVER
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: 20e6
    bw1: 20e6
    center_freq0: freq_112
    center_freq1: freq_112
    comment: Sync and TSB Tag
    gain0: txamp_range
    gain1: txamp_range
    gain_type0: normalized
    gain_type1: normalized
    len_tag_name: '"len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}

connections:
- [ieee80211cu_genpkt_0, '0', ieee80211cu_modcu_0, '0']
- [ieee80211cu_modcu_0, '0', uhd_usrp_sink_0_0, '0']
- [ieee80211cu_modcu_0, '1', uhd_usrp_sink_0_0, '1']
- [network_socket_pdu_0, pdus, ieee80211cu_genpkt_0, pdus]

metadata:
  file_format: 1
