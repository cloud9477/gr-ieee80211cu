options:
  parameters:
    generate_options: no_gui
    id: txcu
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: ieee80211cu_genpkt_0
  id: ieee80211cu_genpkt
  parameters:
    tag: packet_len
  states: {}
- name: ieee80211cu_modcu_0
  id: ieee80211cu_modcu
  parameters: {}
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9528'
    type: UDP_SERVER
  states: {}

connections:
- [ieee80211cu_genpkt_0, '0', ieee80211cu_modcu_0, '0']
- [ieee80211cu_modcu_0, '0', blocks_null_sink_0, '0']
- [ieee80211cu_modcu_0, '1', blocks_null_sink_1, '0']
- [network_socket_pdu_0, pdus, ieee80211cu_genpkt_0, pdus]

metadata:
  file_format: 1
