options:
  parameters:
    category: '[ieee80211cu]'
    generate_options: hb
    id: presisocu
    output_language: python
    title: preproccu
  states: {}

blocks:
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: The first 16 samples are 0
    delay: '63'
    type: complex
  states: {}
- name: ieee80211cu_preproccu_0
  id: ieee80211cu_preproccu
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: preac
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: preconj
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: prein
    type: complex
  states: {}

connections:
- [blocks_delay_0, '0', ieee80211cu_preproccu_0, '0']
- [ieee80211cu_preproccu_0, '0', pad_sink_0, '0']
- [ieee80211cu_preproccu_0, '1', pad_sink_2, '0']
- [pad_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
